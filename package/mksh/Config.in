## package/mksh/Config.in
```kconfig
config BR2_PACKAGE_MKSH
	bool "mksh"
	help
	  MirOS Korn Shell

	  https://www.mirbsd.org/mksh.htm
```
